options:
  parameters:
    author: slamnia
    generate_options: qt_gui
    id: Emission_AM
    output_language: python
    title: Emission_AM
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, 1+1j]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '20'
    value: '1'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '50'
    stop: '10000'
    value: '0'
  states: {}
- name: pskType
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '8'
    value: '1'
  states: {state: disabled}
- name: pskType
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sampPerSymbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 2**7
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: 2**7
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/slamnia/Téléchargements/Best of des pires blagues de jamy.wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon
    freq_offset: offset
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sampPerSymbol
  states: {state: disabled}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: 2**pskType
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: sampPerSymbol
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: 2**pskType
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: sampPerSymbol
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}
- name: vocoder_cvsd_encode_fb_0
  id: vocoder_cvsd_encode_fb
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}

connections:
- [blocks_char_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_char_0, '0', digital_psk_mod_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_char_0, '0']
- [blocks_wavfile_source_0, '0', vocoder_cvsd_encode_fb_0, '0']
- [channels_channel_model_0, '0', digital_psk_demod_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_psk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_psk_demod_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [digital_psk_mod_0, '0', channels_channel_model_0, '0']
- [digital_psk_mod_0, '0', qtgui_const_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', rational_resampler_xxx_0, '0']
- [vocoder_cvsd_encode_fb_0, '0', digital_psk_mod_0, '0']

metadata:
  file_format: 1
