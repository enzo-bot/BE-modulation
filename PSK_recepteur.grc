options:
  parameters:
    author: slamnia
    generate_options: qt_gui
    id: Emission_AM
    output_language: python
    title: Emission_AM
  states: {}

blocks:
- name: CMA_algo
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '500000000'
  states: {}
- name: loop_bandwidth
  id: variable
  parameters:
    value: '0.06'
  states: {}
- name: pskType
  id: variable
  parameters:
    value: '2'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: sampPerSymbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 44100*8
  states: {}
- name: taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '23000'
    low_cutoff_freq: '150'
    samp_rate: samp_rate
    type: band_pass
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: testVar
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '10'
    value: '4'
  states: {state: disabled}
- name: timeErrorDetectionGain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: 2**pskType
    w: loop_bandwidth
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    adapt_after_training: 'False'
    alg: CMA_algo
    num_taps: '5'
    sps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: loop_bandwidth
    max_dev: '1.5'
    osps: '1'
    sps: '1'
    taps: taps
    type: ccf
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: 2**pskType
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: sampPerSymbol
    timing_bw: 6.28/100.0
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '4'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: timeErrorDetectionGain
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}

connections:
- [digital_costas_loop_cc_0, '0', digital_psk_demod_0, '0']
- [digital_linear_equalizer_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_psk_demod_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [iio_pluto_source_0, '0', digital_linear_equalizer_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
