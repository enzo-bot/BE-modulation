options:
  parameters:
    generate_options: qt_gui
    id: Eli
    output_language: python
    title: observation_spectre1
  states: {}

blocks:
- name: bw_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1000000'
    stop: '100000000'
    value: '10000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '900000000'
  states: {}
- name: cf_range
  id: variable_qtgui_range
  parameters:
    start: '70000000'
    step: '10000000'
    stop: '6000000000'
    value: '2000000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bw_range
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: cf_range
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bw_range
    fc: cf_range
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dev_args: '""'
    gain0: '50'
    samp_rate: bw_range
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
