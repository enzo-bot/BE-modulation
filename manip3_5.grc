options:
  parameters:
    author: slamnia
    generate_options: qt_gui
    id: manip3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 87.5e6
    step: 500e3
    stop: 108e6
    value: 100e6
  states: {}
- name: panning
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 44100*7*5
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.3'
    stop: '10'
    value: '1'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: decimation
    audio_pass: cutoff_freq/2
    audio_stop: cutoff_freq
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '44100'
    max_dev: 5e3
    quad_rate: 44100*7
    tau: '75e-6'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters: {}
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/decimation
  states: {state: disabled}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/decimation
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume*panning
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume*panning
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume*(1-panning)
    type: float
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.1*cutoff_freq
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '17'
    interp: '3'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '17'
    interp: '3'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '17'
    interp: '3'
    taps: ''
    type: fff
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: bandwidth
    center_freq0: freq_range
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0_0_1, '0']
- [analog_wfm_rcv_pll_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', rational_resampler_xxx_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', audio_sink_0_0, '1']
- [blocks_multiply_const_vxx_0_0_0_1, '0', audio_sink_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [rational_resampler_xxx_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
