options:
  parameters:
    author: slamnia
    generate_options: qt_gui
    id: Emission_AM
    output_language: python
    title: Emission_AM
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '433500000'
  states: {}
- name: composante_continue
  id: variable_qtgui_range
  parameters:
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {state: disabled}
- name: freq_filtre
  id: variable_qtgui_range
  parameters:
    start: '20'
    step: '1'
    stop: '20000'
    value: '40'
  states: {state: disabled}
- name: freq_modulant
  id: variable_qtgui_range
  parameters:
    start: '20'
    step: '20'
    stop: '20000'
    value: '40'
  states: {state: disabled}
- name: gain_filtre
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '1000'
    value: '1'
  states: {state: disabled}
- name: indice_mod
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '88200'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: '-center_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: freq_filtre
    decim: '1'
    gain: gain_filtre
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: '441'
    taps: ''
    type: ccf
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: '20000'
    center_freq0: center_freq
    dev_args: '""'
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0_0, '1']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
