options:
  parameters:
    author: slamnia
    generate_options: qt_gui
    id: manip3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '6'
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    start: 87.5e6
    step: 500e3
    stop: 108e6
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.3'
    stop: '10'
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/decimation
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.1*cutoff_freq
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '17'
    interp: '3'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: bandwidth
    center_freq0: freq_range
    dev_args: '""'
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
